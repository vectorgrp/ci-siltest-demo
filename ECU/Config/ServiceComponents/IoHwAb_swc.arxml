<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-1-2.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="f3031cc8-f367-42cb-b2b2-331e67ef4724">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="85615ed0-70ae-4f1e-9ab6-13202a8f8161">
          <SHORT-NAME>IoHwAb_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="3ebed031-2410-4e6a-a854-8fc0967a0bf0">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="760173c8-2a24-42b8-a351-a4dbeee0714f">
                  <SHORT-NAME>BaseTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2b8a81b7-2cff-4380-ae4b-9f356579e55a">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="70fc4472-d241-44e2-8990-0075a8dfbae3">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="c7e78f54-b396-410b-acdc-468b3f2c366a">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
